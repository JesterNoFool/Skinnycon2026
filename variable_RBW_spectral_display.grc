options:
  parameters:
    generate_options: qt_gui
    id: basic_spectral_display
    output_language: python
    title: Basic Spectral Display
  states: {}

blocks:
- name: N
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,10,1,10
    label: 'FFT Size: '
    type: real
    value: 2**13
  states: {}
- name: Nd
  id: variable
  parameters:
    comment: |-
      Number of data samples
      based on the desired RBW.
    value: int(samp_rate*nenbw/rbw)
  states: {}
- name: cpg
  id: variable
  parameters:
    comment: |-
      Coherent power gain
      -----------------------------
      Value: (np.sum(w)/Nd)**2
    value: (np.sum(w)/Nd)**2
  states: {}
- name: ipg
  id: variable
  parameters:
    comment: |-
      Incoherent power gain
      -------------------------------
      Value: np.sum(np.power(w,2))/Nd
    value: np.sum(np.power(w,2))/Nd
  states: {}
- name: nenbw
  id: variable
  parameters:
    comment: |-
      This is the NENBW of the
      desired window. Due to
      how this flowgraph works,
      it cannot be calculated
      within the flowgraph;
      therefore, the user must
      manually enter the value.
    value: '2.0044'
  states: {}
- name: rbw
  id: variable
  parameters:
    comment: |-
      Desired RBW
      in Hz.
    value: '2000'
  states: {}
- name: rf_gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,20
    label: 'RF Gain (dB): '
    labels: '["-1.0", "1.5", "4.0", "6.5", "9.0", "11.5", "14.0", "16.5", "19.0", "21.5", "24.0", "29.0", "34.0", "42.0"]'
    num_opts: '0'
    options: '[-1.0, 1.5, 4.0, 6.5, 9.0, 11.5, 14.0, 16.5, 19.0, 21.5, 24.0, 29.0, 34.0, 42.0]'
    type: real
    value: '16.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: w
  id: variable
  parameters:
    comment: |-
      Value: window.<window_name>(Nd)
      where "window_name" can be:
      rectangular
      hann
      hamming
      blackman
      blackmanharris
      flattop
      nuttall
      nuttall_cfd
      kaiser*

      *Kaiser also requires a beta value, so
      its use would be something like
      "window.kaiser(Nd,4)", where the
      beta value is 4.
    value: window.blackmanharris(Nd)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      Calculate magnitude
      for each frequency
      point.
    vlen: N
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: |-
      Calculate average for each
      frequency bin.
    length: '20'
    max_iter: '4000'
    scale: 1/20
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Window the data
    const: w
    type: complex
    vlen: Nd
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Calculate logarithm
      (dB) for each frequency
      point and normalize
      for CPG/IPG (user
      defined).
    k: '-10*np.log10(cpg)'
    n: '10'
    vlen: N
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    comment: |-
      This is to deal with a
      bug in the Vector Sink
      block which causes it
      to drop data randomly.
    interp: '2'
    type: float
    vlen: N
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: Zeropad to a power-of-2.
    lengths: (Nd,(N-Nd))
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Nd
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    comment: Create time record for FFT.
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: Nd
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1/Nd,]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    update_time: '0.0001'
    vlen: N
    x_axis_label: Frequency (MHz)
    x_start: '-samp_rate/2e6'
    x_step: samp_rate/N/1e6
    x_units: MHz
    y_axis_label: Amplitude (dBfs)
    y_units: dBfs
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 102.5e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fft
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: fft
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', virtual_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_mux_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
