options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: polyphaseSpectralDisplay
    output_language: python
    title: WOLA Spectral Display
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: binwidth
  id: variable_qtgui_label
  parameters:
    comment: 'Default value: samp_rate/N'
    label: 'Binwidth (Hz): '
    type: real
    value: samp_rate/N
  states: {}
- name: cpg
  id: variable
  parameters:
    comment: |-
      Coherent power gain
      Value: (np.sum(pfbc)/N)**2
    value: (np.sum(pfbc)/N)**2
  states: {}
- name: enbw
  id: variable_qtgui_label
  parameters:
    comment: 'Default value: binwidth*ipg/cpg'
    label: 'ENBW (Hz): '
    type: real
    value: binwidth*ipg/cpg
  states: {}
- name: gain
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,20
    label: 'RF Gain (dB): '
    labels: '["-1.0", "1.5", "4.0", "6.5", "9.0", "11.5", "14.0", "16.5", "19.0", "21.5", "24.0", "29.0", "34.0", "42.0"]'
    num_opts: '0'
    options: '[-1.0, 1.5, 4.0, 6.5, 9.0, 11.5, 14.0, 16.5, 19.0, 21.5, 24.0, 29.0, 34.0, 42.0]'
    type: real
    value: '16.5'
  states: {}
- name: ipg
  id: variable
  parameters:
    comment: |-
      Incoherent power gain
      Value: np.sum(np.power(pfbc,2))/N
    value: np.sum(np.power(pfbc,2))/N
  states: {}
- name: num_ave
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pfb
  id: variable
  parameters:
    comment: 'Value: N*sig.firwin(4*N,samp_rate/(2*N),window=''blackman'',fs=samp_rate)'
    value: N*sig.firwin(4*N,samp_rate/(2*N),window='blackman',fs=samp_rate)
  states: {}
- name: pfbc
  id: variable
  parameters:
    comment: |-
      Normalize the amplitudes
      of the filter taps
    value: pfb/max(pfb)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: N
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: |-
      Calculate magnitude of
      each frequency bin.
    vlen: N
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
    vlen: N
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '2'
    type: complex
    vlen: N
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: '3'
    type: complex
    vlen: N
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    comment: Average each frequency bin.
    length: num_ave
    max_iter: '4000'
    scale: 1/num_ave
    type: float
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Final 1/4 of filter taps.
    const: pfbc[3*N:4*N]
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: First 1/4 of filter taps.
    const: pfbc[0:N]
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Third 1/4 of filter taps.
    const: pfbc[2*N:3*N]
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    comment: Second 1/4 of filter taps.
    const: pfbc[N:2*N]
    type: complex
    vlen: N
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Calculate logarithm (dB) of each
      frequency bin.
      ---------------------------------------------
      n: 10
      k: -10*np.log10(cpg)
    k: '-10*np.log10(cpg)'
    n: '10'
    vlen: N
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1/N,]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: import_1
  id: import
  parameters:
    comment: 'Import: import scipy.signal as sig'
    imports: import scipy.signal as sig
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The blocks from the Delay to the Add replace the typical windowing block (Multiply Const). This
      requires more processing (just as does any overlapped FFT setup), and replaces the window values with
      FIR lowpass filter taps.
    note: Polyphase Filter Bank
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    update_time: '0.0001'
    vlen: N
    x_start: '-samp_rate/2e6'
    x_step: samp_rate/N/1e6
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 91.9e6
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: filtered
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: filtered
  states: {}

connections:
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_delay_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '2']
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_delay_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', fft_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
